# Keil uVision project ARM_Project2.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ARM_Project2hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./keil/: delay.c
    ./: Startup.s
    ./ARM_P2/: ADC_init.c envi_main.c gpio_init.c lcd_driver.c ldr_read.c led_init.c soil_read.c temp_read.c uart0_init.c water_read.c
